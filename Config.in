## Config.in
```kconfig
config BR2_PACKAGE_MYTEST
	bool "mytest"
	depends on BR2_PACKAGE_FFMPEG
	help
	  This is a comment that explains what mytest is. The help text
	  should be wrapped.
```
